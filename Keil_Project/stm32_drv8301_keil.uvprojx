# Keil uVision project stm32_drv8301_keil.uvprojx, settings and files
target stm32_drv8301 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32_drv8301_keil
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F446xx,ARM_MATH_CM4,USE_USB_OTG_FS,SIMULINK_USE_ARM_MATH,__FPU_PRESENT
  c include: ..\user;..\user\hardware;..\user\interface;..\user\app;..\motor;..\motor\control;..\motor\sensors;..\motor\drivers;..\motor\identification;..\motor\enhancement;..\Libraries;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\user\pc_communication\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f446xx.s
    ../Libraries/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../Libraries/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group motor
    ../motor/drivers/: adc.c drv8301.c
    ../motor/control/: foc_algorithm.c low_task.c speed_pid.c speed_adrc.c
    ../motor/sensors/: hall_sensor.c hybrid_observer.c
    ../motor/identification/: L_identification_wrapper.c R_flux_identification_wrapper.c stm32_ekf_wrapper.c
    ../motor/enhancement/: pid_autotune.c
    ../motor/: foc_define_parameter.h
  group user
    ../user/hardware/: board_config.c
    ../user/app/: exti.c main.c
    ../user/interface/: oled.c oled_display.c oled_font.c USART2.c UpperComputer.c
    ../user/: stm32f4xx_it.c
